# Repository grahamshaw1972/TeensyNumPad

File README.md:

# TeensyNumPad
 Amiga Layout Numpad using Teensy++ 2.0 micro controller. The V1.3 board looks like this when completed and populated with keycaps:

## KiCad design teensyNumPadKicad/teensyNumPadKicad.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: D_Small; D_DO-35_SOD27_P7.62mm_Horizontal
J1: KCDX-5S-S2; KCDX5SS2; Manufacturer_Part_Number KCDX-5S-S2
LED1, LED2, LED3, LED4, LED5, LED6: LED; LED_D3.0mm
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX17: MX-NoLED; MX-1U-NoLED
MX16, MX18: MX-NoLED; MX-2U-NoLED
MX19, MX20, MX21: MX-LED; MX-1.25U
R1, R2, R3, R4, R5, R6, R7, R8, R9: 150; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: Teensy++2.0_(C); Teensy2.0++

Connections:
COL0: MX1.1 (COL), MX5.1 (COL), MX9.1 (COL), MX13.1 (COL), U1.13 (PC0)
COL1: MX2.1 (COL), MX6.1 (COL), MX10.1 (COL), MX14.1 (COL), MX16.1 (COL), U1.14 (PC1)
COL2: MX3.1 (COL), MX7.1 (COL), MX11.1 (COL), MX15.1 (COL), MX17.1 (COL), U1.15 (PC2)
COL3: MX4.1 (COL), MX8.1 (COL), MX12.1 (COL), MX18.1 (COL), U1.16 (PC3_T3)
CTRL: MX20.2, R8.2, U1.39 (PB3_MISO)
GND: J1.5, LED1.1 (K), LED2.1 (K), LED3.1 (K), LED4.1 (K), LED5.1 (K), LED6.1 (K), MX19.4, MX20.4, MX21.4, U1.1 (GND)
KCLK: J1.3, R2.1, U1.25 (PF6_ADC6)
KDAT: J1.2, R3.1, U1.24 (PF7_ADC7)
LAMI: MX19.2, R7.2, U1.42 (PB6_OC1B)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: LED1.2 (A), R1.2
unnamed: LED2.2 (A), R2.2
unnamed: LED3.2 (A), R3.2
unnamed: LED4.2 (A), R4.2
unnamed: LED5.2 (A), R5.2
unnamed: LED6.2 (A), R6.2
unnamed: MX19.3, R7.1
unnamed: MX20.3, R8.1
unnamed: MX21.3, R9.2
RAMI: MX21.2, R9.1, U1.38 (PB2_MOSI)
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), U1.3 (PD0_INT0_OC0B_SCL)
ROW1: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), U1.4 (PD1_INT1_OC2B_SDA)
ROW2: D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.5 (PD2_INT2_RXD1)
ROW3: D13.1 (K), D14.1 (K), D15.1 (K), U1.6 (PD3_INT3_TXD1)
ROW4: D16.1 (K), D17.1 (K), D18.1 (K), U1.7 (PD4_ICP1)
STA1: R4.1, U1.26 (PF5_ADC5)
STA2: R5.1, U1.27 (PF4_ADC4)
STA3: R6.1, U1.28 (PF3_ADC3)
VCC: J1.4, MX19.1, MX20.1, MX21.1, R1.1, U1.43 (VCC)

Board: 2 copper layers, 82.6 x 177.0 mm, 56 parts (0 on the bottom side), 46 nets.

## Code that names these connections

File firmware/qmk_firmware/keyboards/kb/kb.h:

/* Copyright 2021 REPLACE_WITH_YOUR_NAME
 *
 * This program is free software: you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation, either version 2 of the License, or
 * (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 */

#pragma once

#include "quantum.h"

__attribute__((weak)) void matrix_init_user(void);

void amikb_sendkey(unsigned char keycode, int press);
void amikb_wait_for_ack_resync_if_none(void);
void amikb_wait_for_ack_reset_if_none(long timeout);
void wait_for_amiga(long timeout);
void amikb_reset(void);
void hard_reset(void);
void init_timer(void);
void reset_timer(void);
unsigned long get_msec(void);

// ACLK == KCLK == F6
#define ACLK	6
#define ACLK_BIT	(1 << ACLK)

// ADATA == KDAT == F7
#define ADATA	7
#define ADATA_BIT	(1 << ADATA)

#define PIN_CTRL 3
#define CTRL_BIT	(1 << PIN_CTRL)
#define PIN_LAMI 6
#define LAMI_BIT	(1 << PIN_LAMI)
#define PIN_RAMI 2
#define RAMI_BIT	(1 << PIN_RAMI)

#define TIMEOUT_MSEC 143
#define RESET_WARNING_MSEC 250
#define RESET_MSEC 500
#define RESET_WARNING_FULL_MSEC 10000

/*
 * STA3  STA2  STA1  KDAT  KCLK  VCC
 *  F3    F4    F5    F7    F6
 */

#define STA3 F3
#define STA2 F4
#define STA1 F5
#define KDAT F7
#define KCLK F6

#define LAMI B6
#define CTRL B3
#define RAMI B2

#define LAYOUT( \
    K00, K01, K02, K03,   \
    K10, K11, K12, K13,   \
    K20, K21, K22, K23,   \
    K30, K31, K32, K43,   \
    K41,      K42         \
) { \
    { K00,   K01,   K02,   K03   }, \
    { K10,   K11,   K12,   K13   }, \
    { K20,   K21,   K22,   K23   }, \
    { K30,   K31,   K32,   KC_NO }, \
    { KC_NO, K41,   K42,   K43   }, \
}

// Amiga Keycodes
#define AKC_RST_WARN 0x78
#define AKC_PLP 0x5A
#define AKC_PRP 0x5B
#define AKC_PDV 0x5C
#define AKC_PML 0x5D
#define AKC_P7  0x3D
#define AKC_P8  0x3E
#define AKC_P9  0x3F
#define AKC_PMN 0x4A
#define AKC_P4  0x2D
#define AKC_P5  0x2E
#define AKC_P6  0x2F
#define AKC_PPL 0x5E
#define AKC_P1  0x1D
#define AKC_P2  0x1E
#define AKC_P3  0x1F
#define AKC_PEN 0x43
#define AKC_P0  0x0F
#define AKC_PDT 0x3C

extern unsigned char amiga_keycode_table[MATRIX_ROWS][MATRIX_COLS];

// generated by KBFirmware JSON to QMK Parser
// https://noroadsleft.github.io/kbf_qmk_converter/

## Commit log

2021-04-17 Added keyboard-layout-editor and kicad directories
2021-04-17 Add submodules
2021-04-17 Added Symbol and Footprint libraries
2021-04-17 Schema Complete.
2021-04-19 Autorouting completed
2021-04-19 Added Gerbers file and ibom.html
2021-04-20 Add Picture
2021-04-24 Added keyboad-firmware-builder directory
    Including README.md file.
2021-05-01 Add teensyNumPadPCB.jpg and link to it in README.md
2021-05-03 Add 5 pin din plug for connection to an Amiga
2021-05-08 Add Modifier keys + LEDs
2021-05-08 Create new gerber files
2021-05-08 Update teensyNumPadKicad.kicad_pcb-bak
2021-05-12 Update Firmware with correct Numpad Keycodes
2021-05-15 Move diodes for 2u keys
    Diode was clashing with stabilizer
2021-06-02 Updated Schema and PCB
    Fixed pin assignments on 5 pin DIN socket as follows:
    1 Not Connected
    2 KDAT
    3 KCLK
    4 +5V
    5 GND
2021-06-02 Update output files
    gerberFiles.zip & ibom.html
2021-06-02 Update picture in readme.md
    Include picture of v1.2 assembled.
2021-06-02 Update to use MX-LED footprints where required
    Use MX-LED footprints for MX-19, MX20 + MX21.
2021-06-06 Add Amiga Firmware
    Initially, just testing Ctrl, L-Amiga + R-Amiga and lighting STA1, STA2 + STA3 when they are pressed...
2021-06-20 qmk_firmware
2021-06-20 Add qmk-firmware
2021-06-20 Light LED in response to key press.
2021-06-20 Update to use standard pin expressions
    Such as writePinHigh(F5)
2021-06-27 Amiga now starts
    Set KCLK to high on start up -> A2000 now starts up with Teensy Numpad connected.
    #define NO_USB_STARTUP_CHECK 1
    This is so that keyboard_task() gets called as required when connected to an A2000.
2021-06-27 Update README.md
    Upddate picture to teensyNumPad1_3Assembled.jpg
2021-06-27 Now sends keycode to Amiga
    Bug where only one key is received by Amiga before we get a blank screen.
2021-06-27 Move timer functions into kb.c
2021-06-30 Fixed the locking up bug
    Needed to raise the clock high after the handshake. Main keypad keys are now all working. Crtl, L-Amiga + R-Amiga are not yet implemented.
2021-07-01 Add housekeeping_task_user()
    Use housekeeping_task_user() to monitor Ctrl, L-Amiga + R-Amiga, generating an event if all three are pressed.
2021-07-03 Add reset code
    Hard reset only.
2021-07-03 Added reset warnings
    Implemented but difficult to test TBH.
2021-07-03 Tidy up definition of Amiga Keycodes and Layout
    Amiga Layout now looks more like PC layout.
2021-07-04 Make sending of reset warning configurable using a #define
    #ifdef SEND_RESET_WARNING
